# Keil uVision project keilproj.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.9.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: code
  AfterMake: fromelf -cvf .\Objects\code.axf --vhx --32x1 -o code.hex
  AfterMake: fromelf -cvf .\Objects\code.axf -o disasm.txt
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Files\Software\core;..\Files\Software\Application;..\Files\Software\device
  asm include: ..\Files\Software\device
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application
    ../Files/Software/Application/: main_1player.c
  group Device
    ../Files/Software/device/: cm0dsasm.s edk_driver.c edk_driver.h EDK_CM0.h edk_api.c edk_api.h retarget.c
  group Core
    ../Files/Software/core/: core_cmFunc.h core_cmInstr.h core_cm0.h
software components: CMSIS:CORE 5.5.0
